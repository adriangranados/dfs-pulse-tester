<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>DFS_Pulse_Tester</value></param>
<param><key>comment</key><value>DFS tester to verify AP DFS operation
using HackRF One SDR.

Contributions:
 - Adrian Granados (original author)
 - Nigel Bowden

v0.01 - 31st Dec 2017 - Initial dev build
v0.02 - 1st Jan 2018 - Added RF gate for on/off function
v0.03 - 4th Jan 2018 - Rearranged UI widgets and set labels</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Channel_Center_Freq</value></param>
<param><key>comment</key><value>List chooser in GUI to select the channel
our HackRF will transmit on - NB</value></param>
<param><key>value</key><value>5260000000</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>labels</key><value>["52 | 5260", "56 | 5280", "60 | 5300", "64 | 5320", "100 | 5500", "104 | 5520", "108 | 5540", "112 | 5560", "116 | 5580", "120 | 5600", "124 | 5620", "128 | 5640", "132 | 5660", "136 | 5680", "140 | 5700"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5520000000, 5540000000, 5560000000, 5580000000, 5600000000, 5620000000, 5640000000, 5660000000, 5680000000, 5700000000]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>DFS_Pattern</value></param>
<param><key>comment</key><value>List chooser to select the DFS
pattern we would like to test - NB</value></param>
<param><key>value</key><value>[1]*15 + [0]*250</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>Radar Signature</value></param>
<param><key>labels</key><value>["FCC Type 0", "FCC Type 1", "FCC Type 2", "FCC Type 3", "FCC Type 4", "ETSI Type 0", "ETSI Type 1", "ETSI Type 2", "ETSI Type 3", "ETSI Type 4", "ETSI Type 5", "ETSI Type 6"]</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>option5</key><value>5</value></param>
<param><key>option6</key><value>6</value></param>
<param><key>option7</key><value>7</value></param>
<param><key>option8</key><value>8</value></param>
<param><key>option9</key><value>9</value></param>
<param><key>option10</key><value>10</value></param>
<param><key>options</key><value>[ [1]*1 + [0]*1428, [1]*1 + [0]*1000, [1]*5 + [0]*200, [1]*8 + [0]*350, [1]*15 + [0]*250, [1]*1 + [0]*1428, [1]*1 + [0]*1000, [1]*2 + [0]*1000, [1]*2 + [0]*300, [1]*25 + [0]*350, [1]*1 + [0]*2500, [1]*1 + [0]*833 ] </value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>Start_Stop</value></param>
<param><key>comment</key><value>GUI on/off switch for RF</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
<param><key>label0</key><value>Stop</value></param>
<param><key>label1</key><value>Start</value></param>
<param><key>label</key><value>Pulse</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>False</value></param>
<param><key>option1</key><value>True</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>blocks_copy</key>
<param><key>id</key><value>blocks_copy_0</value></param>
<param><key>comment</key><value>Gate to switch RF on/off</value></param>
<param><key>enabled</key><value>Start_Stop</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>comment</key><value>Added as suggested by
messages in warning
window of GRC - not
really sure of its impact,
but believe it protects
CPU util - NB</value></param>
<param><key>samples_per_second</key><value>32000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>DFS_Pattern</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>20000000</value></param>
<param><key>freq0</key><value>Channel_Center_Freq</value></param>
<param><key>if_gain0</key><value>40</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>comment</key><value>Sink for SDR (HackRF One)</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>20000000</value></param>
<param><key>fc</key><value>Channel_Center_Freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>comment</key><value>Visualization of the transmitted signal - NB</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_copy_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_copy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
